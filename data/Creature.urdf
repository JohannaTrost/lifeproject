Commit message: set box size in urdf

File: data/Creature.urdf (robot description, URDF)
Before this commit: robot Creature, 5 links, 0 joints
Links:
- removed link B2
- removed link B3
- removed link S_B1/B2
- removed link S_B1/B3
